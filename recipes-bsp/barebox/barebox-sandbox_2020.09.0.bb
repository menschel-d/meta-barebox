require barebox-sandbox.inc

SRC_URI += "file://0001-sandbox-retire-CONFIG_LINUX-symbol-in-favor-of-CONFI.patch"

SRCREV = "ac9607af82dab0f6920efc301b8d1a98a2adde7c"

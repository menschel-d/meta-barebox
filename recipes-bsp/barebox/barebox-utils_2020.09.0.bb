require barebox-utils.inc

SRCREV = "ac9607af82dab0f6920efc301b8d1a98a2adde7c"

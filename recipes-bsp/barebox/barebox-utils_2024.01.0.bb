require barebox-utils.inc

SRCREV = "ba38bf052ff4bf09c47f5f0e42f021dcf3bef557"

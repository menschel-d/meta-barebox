require barebox-sandbox.inc

SRCREV = "7ae6bbdfa69855ee2f46fabda6622875f408fb1c"

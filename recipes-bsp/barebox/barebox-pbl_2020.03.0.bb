require barebox-pbl.inc

SRCREV = "616091af9a09018cef8d0c61b9d5a3812d3926ba"

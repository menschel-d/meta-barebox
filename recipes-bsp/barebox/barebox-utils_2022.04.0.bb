require barebox-utils.inc

SRCREV = "3b79b3e0e5d90ec8cf955f267ec3c8fd2063aafb"

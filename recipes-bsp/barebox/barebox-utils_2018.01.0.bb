require barebox-utils.inc

PR = "r1"

SRC_URI += " \
    file://0001-scripts-compiler.h-inline-functions-in-headers-must-.patch \
"

SRCREV = "1b3990c50f6137efa4c9c95d5344bdda18d92096"

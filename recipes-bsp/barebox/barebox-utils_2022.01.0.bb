require barebox-utils.inc

SRCREV = "32295bee4791b4b2e7ba4faa4621105097a1ca7c"

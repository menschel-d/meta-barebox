require barebox-utils.inc

SRCREV = "c7a3ae7ec058e72adc0dae3ab41e47e475295d41"

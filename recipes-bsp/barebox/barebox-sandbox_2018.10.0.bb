require barebox-sandbox.inc

SRCREV = "38760898976a97041e3666ea693b45bc259584c6"

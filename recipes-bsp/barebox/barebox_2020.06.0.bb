require barebox.inc

SRCREV = "ff087598f4cdc426ba883a8720367a4ff3d6b9fe"

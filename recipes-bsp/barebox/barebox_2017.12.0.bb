require barebox.inc

SRCREV = "d67aed662306dff4b2ab3064ebf81ef86cae1172"

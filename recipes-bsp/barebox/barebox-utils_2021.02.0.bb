require barebox-utils.inc

SRCREV = "20ad171ecf1f71c6ab044042a59c213caef02ecd"

require barebox-pbl.inc

SRCREV = "cff4868b6d11f1c9e296fea8ca1da1224bde7f39"

require barebox-utils.inc

SRCREV = "c881804b51c707a39ba9c8cde86e8ccbb62d3d41"

require barebox-utils.inc

SRCREV = "5b2d69d78c286cea48a49eb2c77cd8e4b790ac4b"

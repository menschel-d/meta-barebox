require barebox.inc

SRCREV = "849b2f8b958a19d28715c187a0d6dca23ccba6b5"

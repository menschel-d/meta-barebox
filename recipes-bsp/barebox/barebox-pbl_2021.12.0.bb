require barebox-pbl.inc

SRCREV = "b21ac7bbd98f9bf21f9753a9974e22f368b6ec1f"

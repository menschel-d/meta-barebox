require barebox-pbl.inc

SRCREV = "b258642b7db16b6a2a47f958357db597251304c9"

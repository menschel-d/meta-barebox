require barebox.inc

SRCREV = "96b7140db7843328e6b25cda77199d84f7b4592e"

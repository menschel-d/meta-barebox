require barebox-sandbox.inc

SRCREV = "a34fd3272a88101483f74a608b07db4312a64015"

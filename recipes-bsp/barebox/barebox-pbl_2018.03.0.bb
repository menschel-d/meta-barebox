require barebox-pbl.inc

SRCREV = "610d8769ed1a620c4a048c625b540a4d8ee14ffb"

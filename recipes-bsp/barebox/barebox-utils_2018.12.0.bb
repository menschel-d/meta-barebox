require barebox-utils.inc

SRCREV = "0b5361a328632e64c14a54306119093a0c7fecdf"

require barebox.inc

SRCREV = "fada08899355634d7d376614453a6a8c557bda0b"

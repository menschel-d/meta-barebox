require barebox-sandbox.inc

SRCREV = "e2c198488f5aa6dadebec88af1db8ae06127b98b"

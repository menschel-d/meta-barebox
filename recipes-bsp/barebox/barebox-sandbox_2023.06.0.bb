require barebox-sandbox.inc

SRCREV = "7033a67d0c7e0f39edbf51a1e0b182b00c6b80ec"

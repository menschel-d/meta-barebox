require barebox-sandbox.inc

SRCREV = "cb4c8b11ef1f71b3eac408c9f46526b2afb402f1"

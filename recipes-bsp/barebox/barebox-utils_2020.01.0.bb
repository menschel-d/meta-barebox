require barebox-utils.inc

SRCREV = "4cce60b7fe2798e81b04c5d9ad79dc9b443635a8"

require barebox-pbl.inc

SRCREV = "f1b22deeb6ed8bfef865990b8404874e66f9b4d7"

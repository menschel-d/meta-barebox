require barebox-utils.inc

PR = "r1"

SRC_URI += " \
    file://0001-scripts-compiler.h-inline-functions-in-headers-must-.patch \
"

SRCREV = "2408090cbdf1ada60271eb84ca81be3e34993a7a"

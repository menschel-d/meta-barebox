require barebox.inc

SRCREV = "a614f64d72812a4c569ae06d6ee81dfdfeea812c"


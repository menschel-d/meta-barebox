require barebox-utils.inc

SRCREV = "14a36bcaec727fce6c27f5117095e316cbcbfa6c"

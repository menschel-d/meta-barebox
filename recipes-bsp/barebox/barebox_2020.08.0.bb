require barebox.inc

SRCREV = "9f0fe7745e458a388066e9a504b77fb5fe2295b2"

require barebox-utils.inc

SRCREV = "94420265227df2bbe221293f9e10466030387209"

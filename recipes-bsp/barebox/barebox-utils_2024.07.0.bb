require barebox-utils.inc

SRCREV = "957dec72a6a83d42b06cb65b5fb5c916067040a9"

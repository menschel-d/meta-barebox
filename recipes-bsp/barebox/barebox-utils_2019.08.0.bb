require barebox-utils.inc

SRCREV = "41122e10f77af5691dce8cc83114d4fd3a9f21f5"

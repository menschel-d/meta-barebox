require barebox-pbl.inc

SRCREV = "1b3990c50f6137efa4c9c95d5344bdda18d92096"

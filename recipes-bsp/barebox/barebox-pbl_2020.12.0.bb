require barebox-pbl.inc

SRCREV = "eac993949c81a166f52d1d1b6857eefdb6c18948"

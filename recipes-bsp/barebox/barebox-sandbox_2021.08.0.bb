require barebox-sandbox.inc

SRCREV = "c67ada0024da66616acd80b01c8c8b454d16f6d8"

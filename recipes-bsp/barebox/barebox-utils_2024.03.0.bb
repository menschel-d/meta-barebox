require barebox-utils.inc

SRCREV = "c6d055d224e0b3a0aff638a05a367c30d2d0310e"

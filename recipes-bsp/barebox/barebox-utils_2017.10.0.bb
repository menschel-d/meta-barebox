require barebox-utils.inc

PR = "r1"

SRC_URI += " \
    file://0001-scripts-compiler.h-inline-functions-in-headers-must-.patch \
"

SRCREV = "b258642b7db16b6a2a47f958357db597251304c9"

require barebox-sandbox.inc

SRC_URI += "file://0001-sandbox-retire-CONFIG_LINUX-symbol-in-favor-of-CONFI.patch"

SRCREV = "ea7fdd5f550a63f45a90f76cb1ac1e1eeecffe00"

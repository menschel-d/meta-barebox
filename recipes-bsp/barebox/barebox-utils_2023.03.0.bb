require barebox-utils.inc

SRCREV = "e068bbf6a3608351484567af19da68e0e382fa0f"

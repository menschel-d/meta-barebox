require barebox-sandbox.inc

SRCREV = "cd4320e3e86bd2ab7b4a19016ef8df6c5d69a5a5"

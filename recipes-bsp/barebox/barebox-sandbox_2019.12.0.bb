require barebox-sandbox.inc

SRCREV = "48b57af0ab888bf88607d0e55ad3e79d13cc0a31"

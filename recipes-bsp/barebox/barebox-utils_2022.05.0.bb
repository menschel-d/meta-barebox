require barebox-utils.inc

SRCREV = "6a3f9ed1f5c55957b2ed4f460955281539e8e785"

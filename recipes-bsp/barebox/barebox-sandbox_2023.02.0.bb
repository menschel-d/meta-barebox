require barebox-sandbox.inc

SRCREV = "ad5bfa7b4ff593d734293a6541170cd5f972eaa0"

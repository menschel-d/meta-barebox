require barebox-pbl.inc

SRCREV = "8d1d3a8d7b8a8325d09105cce2d667efb25f6579"

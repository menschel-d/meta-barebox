require barebox.inc

SRCREV = "89b766c63f94b5fe94db75a6f197c9e6c0f9da7e"

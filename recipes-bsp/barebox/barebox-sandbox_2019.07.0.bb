require barebox-sandbox.inc

SRCREV = "c787d0e619f42436fb25fc584c5d2a9d5903deda"

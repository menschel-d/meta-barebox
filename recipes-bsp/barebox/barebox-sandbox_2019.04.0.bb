require barebox-sandbox.inc

SRCREV = "9688b49cd3bc0b61a019e8e1311236c9975a0777"

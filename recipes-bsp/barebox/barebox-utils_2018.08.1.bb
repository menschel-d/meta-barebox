require barebox-utils.inc

SRCREV = "64b5120759f01f93dc478d2bc19608accfab18f3"

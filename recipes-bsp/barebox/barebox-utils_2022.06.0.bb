require barebox-utils.inc

SRCREV = "512d036587a38c57a30cc63ce48c19c895b9d729"

require barebox.inc

SRCREV = "bc5e49335067d0c6c6e97c082a0368fe9d86b725"

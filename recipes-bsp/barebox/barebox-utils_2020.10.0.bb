require barebox-utils.inc

SRCREV = "ea7fdd5f550a63f45a90f76cb1ac1e1eeecffe00"

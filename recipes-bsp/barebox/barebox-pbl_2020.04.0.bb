require barebox-pbl.inc

SRCREV = "a999dc558770732d475e423060d54b93e36436ce"

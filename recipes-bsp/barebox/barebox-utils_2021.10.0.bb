require barebox-utils.inc

SRCREV = "dc9f4c29bece2cc66946f56cef9c5868afa92838"

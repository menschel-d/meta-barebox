require barebox.inc

SRCREV = "72424fd057d135ec0e41139fe4cb5740471d33a5"

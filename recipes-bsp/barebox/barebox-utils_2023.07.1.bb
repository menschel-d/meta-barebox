require barebox-utils.inc

SRCREV = "0186c17838e655dbf6a3bcd01fa74821d5e67ae6"

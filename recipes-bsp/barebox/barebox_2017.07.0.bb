require barebox.inc

SRCREV = "cd7d4469687871e483b9adda3febb11621e23ef5"

require barebox.inc

SRCREV = "bd9ad3a602295fb9aa8882fbf27c54288b150d5f"

require barebox-utils.inc

SRCREV = "ed7c14536d521793199abf0597164a46ba68e8e5"

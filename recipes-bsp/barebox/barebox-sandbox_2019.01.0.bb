require barebox-sandbox.inc

SRCREV = "60e12093cf3288086b62612bb3cf565a0b4320aa"

require barebox.inc

SRCREV = "e7e8440c308677e2d11f508a81bffbe56223577e"

require barebox-pbl.inc

SRCREV = "fbde027fdb1d8725253787dd3416702255e646f7"

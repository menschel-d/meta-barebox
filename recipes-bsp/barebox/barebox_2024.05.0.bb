require barebox.inc

SRCREV = "bafdf4b35d777d159ac4058efc86d36622ce5ccf"

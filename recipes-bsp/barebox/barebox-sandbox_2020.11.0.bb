require barebox-sandbox.inc

SRC_URI += "file://0001-sandbox-retire-CONFIG_LINUX-symbol-in-favor-of-CONFI.patch"

SRCREV = "89b766c63f94b5fe94db75a6f197c9e6c0f9da7e"

require barebox.inc

SRCREV = "f56ff878cf869ef4c1b0bdf122710c57341c76f9"
SRCBRANCH = "stable/v2018.07"

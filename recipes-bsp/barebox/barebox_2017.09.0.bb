require barebox.inc

SRCREV = "2408090cbdf1ada60271eb84ca81be3e34993a7a"

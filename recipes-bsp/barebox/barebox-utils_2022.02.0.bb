require barebox-utils.inc

SRCREV = "179eeaeb5ed73d2b49b1494b5e058009b5fb9a0d"

require barebox-utils.inc

SRCREV = "12df451f3e595d91657d8a1763624a4f4e8c17c0"

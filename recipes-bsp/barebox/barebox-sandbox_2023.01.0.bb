require barebox-sandbox.inc

SRCREV = "5a01515c0bb8e8c3093c083a1cd2891c706f310d"

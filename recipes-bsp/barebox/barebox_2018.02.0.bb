require barebox.inc

SRCREV = "c26d219a45ebe39e675c6148602b08f69edfa08e"

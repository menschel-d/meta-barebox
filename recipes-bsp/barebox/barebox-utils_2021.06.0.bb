require barebox-utils.inc

SRCREV = "3d751d09c17eb049425cf98547715e7028da9223"

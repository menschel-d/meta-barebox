require barebox-utils.inc

SRC_URI += " \
    file://0001-scripts-compiler.h-inline-functions-in-headers-must-.patch \
"

SRCREV = "c26d219a45ebe39e675c6148602b08f69edfa08e"

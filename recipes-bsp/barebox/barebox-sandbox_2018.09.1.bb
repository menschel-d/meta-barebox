require barebox-sandbox.inc

SRCREV = "dc6f695e4d2734e8e5e7478741b1268093b41498"
SRCBRANCH = "stable/v2018.09"

require barebox.inc

SRCREV = "1f31cde526d4e251da6464cac42ee2252643b972"

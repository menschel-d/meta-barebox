require barebox-sandbox.inc

SRCREV = "ea244737e796ffc5be9c4373742e8f88f0c5ff3b"

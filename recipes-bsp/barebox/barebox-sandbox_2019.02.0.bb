require barebox-sandbox.inc

SRCREV = "8575f9d51607dcc46ba2787193bfaff52deb7ae9"

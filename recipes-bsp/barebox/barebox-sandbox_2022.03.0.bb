require barebox-sandbox.inc

SRCREV = "abec545181e2d2a098afc6ac99d44e3ba2d98f63"

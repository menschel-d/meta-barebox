require barebox-sandbox.inc

SRCREV = "605737eceb5af862ddffc8659629c3587de94d1d"

require barebox-targettools.inc

SRCREV = "d214d22650d97c421d34fcaf62f6ffa32e1abb39"


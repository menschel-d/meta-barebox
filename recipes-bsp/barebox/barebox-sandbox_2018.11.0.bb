require barebox-sandbox.inc

SRCREV = "d1f223eddbcde31ba2a3f34fc0a1a14f40ea7130"

require barebox-sandbox.inc

SRCREV = "9f8e6f6a38a8f9351ea110eae9ff0dc62fde5220"

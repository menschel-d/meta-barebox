require barebox.inc

SRCREV = "dee788e9b341044da782e77fe627ffdaeaf10756"

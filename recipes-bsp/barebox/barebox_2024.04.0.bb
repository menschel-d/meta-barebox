require barebox.inc

SRCREV = "cceb4ee7619a2601eeb0e2f976ec65e0247bc8c3"

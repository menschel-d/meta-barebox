require barebox.inc

SRCREV = "ce40a01f804a50433ace02c43cbc6c24dfe4d458"

require barebox-sandbox.inc

SRCREV = "3322880d50b964c17021f9a6089d191b6cf1586b"

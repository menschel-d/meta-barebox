require barebox-sandbox.inc

SRC_URI += "file://0001-scripts-bareboximd-add-mode-argument-to-open-call.patch"

SRCREV = "616091af9a09018cef8d0c61b9d5a3812d3926ba"

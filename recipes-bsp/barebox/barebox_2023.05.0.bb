require barebox.inc

SRCREV = "630e1e2232c9ce710939dd47e592ad365889c854"

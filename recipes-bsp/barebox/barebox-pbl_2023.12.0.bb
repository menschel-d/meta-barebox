require barebox-pbl.inc

SRCREV = "ed433cbef99860b39dfbc2d36983026cced54583"

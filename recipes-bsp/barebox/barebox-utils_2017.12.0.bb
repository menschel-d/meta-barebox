require barebox-utils.inc

PR = "r1"

SRC_URI += " \
    file://0001-scripts-compiler.h-inline-functions-in-headers-must-.patch \
"

SRCREV = "d67aed662306dff4b2ab3064ebf81ef86cae1172"

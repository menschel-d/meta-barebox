require barebox-utils.inc

SRCREV = "a9a07aa1cd94b30335e0c82c8d36e9bc7d784e49"

require barebox-utils.inc

PR = "r1"

SRC_URI += " \
    file://0001-scripts-compiler.h-inline-functions-in-headers-must-.patch \
"

SRCREV = "5f5decec00df364859fd375dde8c0e2c148447d1"

require barebox-pbl.inc

SRCREV = "5f200dd534c848dfa5d948334b6373f0310b8f73"

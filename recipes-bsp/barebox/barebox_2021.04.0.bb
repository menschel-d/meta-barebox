require barebox.inc

SRCREV = "648bbfb107f4df7c7a8486d6228fbc6bef63b546"

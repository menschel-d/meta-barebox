require barebox.inc

SRCREV = "9b4ee03a2b47715384b0e92a64935fa220033f32"
